# Repository MechatronixLab/STM32XP (continued)

## KiCad design HARDWARE/KICAD/STM32XP.kicad_pcb (continued)

Parts:
C20, C21, C22, C23, C28, C30, C33, C34, C38, C39: 100nF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C29: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D9: ESDA6V1-5SC6; SOT-23-6
J3: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Horizontal
R24, R25, R26, R27, R35, R36, R39, R40: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U6: LM324; TSSOP-14_4.4x5mm_P0.65mm
U7: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm

Connections:
+5VA: C27.2, C28.2, C29.2, C30.2, J3.5, U6.4 (V+), U7.8 (VDD); also elsewhere on the board
/ANALOG/AA1+: C21.2, R27.2, U6.3 (+)
/ANALOG/AA1FB: C23.1, R25.2, R27.1
/ANALOG/AA2+: C20.2, R26.2, U6.5 (+)
/ANALOG/AA2FB: C22.1, R24.2, R26.1
/ANALOG/AA3+: C38.2, R35.2, U6.10 (+)
/ANALOG/AA3FB: C33.1, R35.1, R39.2
/ANALOG/AA4+: C39.2, R36.2, U6.12 (+)
/ANALOG/AA4FB: C34.1, R36.1, R40.2
A0: D9.1 (IO1), J3.1, R25.1
A1: D9.3 (IO2), J3.3, R24.1
A2: D9.4 (IO3), J3.7, R39.1
A3: D9.6 (IO5), J3.9, R40.1
AIN0: C23.2, U6.1, U6.2 (-), U7.4 (AIN0)
AIN1: C22.2, U6.6 (-), U6.7, U7.5 (AIN1)
AIN2: C33.2, U6.8, U6.9 (-), U7.6 (AIN2)
AIN3: C34.2, U6.13 (-), U6.14, U7.7 (AIN3)
GND: C20.1, C21.1, C27.1, C28.1, C29.1, C30.1, C38.1, C39.1, D9.2 (GND), D9.5 (IO4), J3.2, J3.4, J3.6, J3.8, J3.10, U6.11 (V-), U7.1 (ADDR), U7.3 (GND); also elsewhere on the board
I2C SCL 5V: U7.10 (SCL); also elsewhere on the board
I2C SDA 5V: U7.9 (SDA); also elsewhere on the board

Parts:
C1, C6: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C12: 100nF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D5: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D10: 150505M173300; WE 150505M173300
LS1: 78dB 4kHz; PKM13EPYH4000-A0
Q1: 2N7002; SOT-23
R8: 1K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R46, R47, R49, R50, R51, R52, R53: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW2: UP; SW_Push_1P1T_NO_CK_KSC6xxJ
SW3: LEFT; SW_Push_1P1T_NO_CK_KSC6xxJ
SW4: CENTER; SW_Push_1P1T_NO_CK_KSC6xxJ
SW5: RIGHT; SW_Push_1P1T_NO_CK_KSC6xxJ
SW6: BUTTON 1; SW_Push_1P1T_NO_CK_KSC6xxJ
SW7: BUTTON 2; SW_Push_1P1T_NO_CK_KSC6xxJ
SW8: DOWN; SW_Push_1P1T_NO_CK_KSC6xxJ
U4: OLED 128x64 1.3"; OLED 128x64 1.3in

Connections:
+3.3V: C6.2, C12.2, R46.2, R47.2, R49.2, R50.2, R51.2, R52.2, R53.2, U4.1 (VCC); also elsewhere on the board
+5V: C3.2, D5.1 (VDD); also elsewhere on the board
+9V: C1.2, LS1.1, R8.2; also elsewhere on the board
/INTERFACE/BUZZER DRAIN: LS1.2, Q1.3 (D), R8.1
BUTTON 1: R50.1, SW6.2; also elsewhere on the board
BUTTON 2: R51.1, SW7.2; also elsewhere on the board
BUTTON CENTER: R47.1, SW4.2; also elsewhere on the board
BUTTON DOWN: R53.1, SW8.2; also elsewhere on the board
BUTTON LEFT: R52.1, SW3.2; also elsewhere on the board
BUTTON RIGHT: R49.1, SW5.2; also elsewhere on the board
BUTTON UP: R46.1, SW2.2; also elsewhere on the board
GND: C1.1, C3.1, C6.1, C12.1, D5.3 (VSS), D10.1 (KB), D10.3 (KR), D10.5 (KG), Q1.2 (S), SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, U4.2 (GND); also elsewhere on the board
I2C SCL 3.3V: U4.3 (SCL); also elsewhere on the board
I2C SDA 3.3V: U4.4 (SDA); also elsewhere on the board
NEOPIXEL DIN: D5.4 (DIN); also elsewhere on the board
NEOPIXEL DOUT: D5.2 (DOUT); also elsewhere on the board
PWM BLUE: D10.2 (AB); also elsewhere on the board
PWM BUZZER: Q1.1 (G); also elsewhere on the board
PWM GREEN: D10.6 (AG); also elsewhere on the board
PWM RED: D10.4 (AR); also elsewhere on the board

Notes on the sheet:
2024.08.09: 10K PULL-DOWN RESISTOR ADDED TO GATE, TO PREVENT NOISE WHEN HANDLING THE BOARD

Board: 4 copper layers, 99.1 x 68.6 mm, 173 parts (9 on the bottom side), 120 nets.

File HARDWARE/KICAD/production/STM32XP - BOM REV.00.xlsx (part):

|  |  |  |  | SPEC |  |  |  |  | JLCPCB
# | DESIGNATOR | VALUE | FOOTPRINT | QTY. | MPN | MANUFACTURER | DATASHEET | 3D MODEL | NOTES | LCSC Part # | LCSC MPN | LCSC MANUFACTURER
1 | BT1 | CR2032 | CR2032 | 1 | 79527141 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/7952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 | https://www.we-online.com/components/products/download/79527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 | - | - | - | -
2 | C1, C10, C13, C19, C2, C27, C29, C36, C37, C4, C40, C44, C6, C7, C8, C9 | 10uF 16V | CAP_0805 | 16 | KGM21AR71C106K | KYOCERA/AVX | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | KICAD CAP 0603 | - | C15850 | CL21A106KAYNNNE | SAMSUNG
3 | C11, C12, C17, C18, C20, C21, C22, C23, C24, C26, C28, C3, C30, C32, C33, C34, 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 | 100nF 50V | CAP_0603 | 24 | KGM15BR71H104K | KYOCERA/AVX | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | KICAD CAP 0603 | - | C14663 | CC0603KRX7R9BB104 | YAGEO
4 | C14, C15, C25, C31 | 10pF 50V | CAP_0603 | 4 | KGM15ACG1H100G | KYOCERA/AVX | https://datasheets.kyocera-avx.com/C0GNP0-KGM.pdf | KICAD CAP 0603 | - | C1634 | CL10C100JB8NNNC | SAMSUNG
5 | C16 | 680nF 16V | CAP_0603 | 1 | KGM15BR71C684M | KYOCERA/AVX | https://datasheets.kyocera-avx.com/KGM_X7R.pdf | KICAD CAP 0603 | - | C327005 | CC0603KRX5R8BB684 | YAGEO
6 | D1, D3, D4, D7, D8 | LED | LED_0603 | 5 | 150060SS55040 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/1500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 | KICAD LED 0603 | - | C128052 | 19-213/R6C-AM2P1VY/3T | EVERLIGHT
7 | D10 | 150505M173300 | WE 150505M173300 | 1 | 150505M173300 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/1505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 | https://www.we-online.com/components/products/download/Downl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 | - | - | - | -
8 | D2 | STPS1L40-Y | D_SOD-123 | 1 | STPS1L40ZFY | STMICROELECTRONICS | https://www.st.com/resource/en/datasheet/stps1l40-y.pdf | KICAD SOD-123 | - | C82544 | 1N5819HW-7-F | DIODES INCORPORATED
9 | D5 | WS2812B | LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm | 1 | 1315050930002 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/1315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 | https://www.we-online.com/components/products/download/IGS_W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 | - | - | - | -
10 | D6 | BAT54C | SOT-23 | 1 | BAT54C-7-F | DIODES INCORPORATED | https://www.diodes.com/datasheet/download/BAT54C.pdf | KICAD SOT-23-3 | CHANGE TO 2X 1N5819HW | C916424 | BAT54C | JSMSEMI
11 | D9 | ESDA6V1-5SC6 | SOT-23-6 | 1 | ESDA6V1-5SC6 | STMICROELECTRONICS | https://www.st.com/resource/en/datasheet/esda6v1-5sc6.pdf | KICAD SOT-23-6 | - | C2827672 | ESDA6V1-5SC6 | TECH PUBLIC
12 | FB1, FB2, FB3 | 600R | 0603 | 3 | 742792651 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/7427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 | KICAD FB 0603 | - | C963865 | ACMS160808A1213A | HYHONGYEX
13 | FID1, FID2, FID3 | Fiducial | Fiducial_0.75mm_Mask1.5mm | 3 | - | - | - | - | DO NOT PLACE | - | - | -
14 | H1, H2, H3, H4 | MountingHole | MountingHole_3.2mm_M3 | 4 | - | - | - | - | DO NOT PLACE | - | - | -
15 | J1, J6 | Conn_01x20_Socket | PinSocket_1x20_P2.54mm_Horizontal | 2 | 613020143121 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/6130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 | https://www.we-online.com/components/products/download/61302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 | THRU HOLE | - | - | -
16 | J2 | Jack-DC | BarrelJack_GCT_DCJ200-10-A_Horizontal | 1 | 694108301002 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/6941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 | https://www.we-online.com/components/products/download/Downl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 | THRU HOLE | - | - | -
17 | J3 | Conn_02x05_Odd_Even | PinSocket_2x05_P2.54mm_Horizontal | 1 | 613010243121 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/6130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 | https://www.we-online.com/components/products/download/Downl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 | THRU HOLE | - | - | -
18 | J4 | USB TYPE C | USB_C_Receptacle_G-Switch_GT-USB-7010ASV | 1 | 629722000214 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/6297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 | https://www.we-online.com/components/products/download/IGES_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 | - | C2927038 | USB-TYPE-C-018 | DEALON
19 | J5 | MICRO SD | WE 693071020811 | 1 | 693071020811 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/6930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 | https://www.we-online.com/components/products/download/Downl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 | - | C19189038 | HX TF-CARD H1.8 SY | HANXIA
20 | JP1 | 9V | SolderJumper | 1 | - | - | - | - | DO NOT PLACE | - | - | -
21 | JP2 | VSEL | SolderJumper | 1 | - | - | - | - | DO NOT PLACE | - | - | -
22 | L1 | 10uH | WE 74404024100 | 1 | 74404024100 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/7440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 | https://www.we-online.com/components/products/download/WE-LQ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 | - | C520138 | CMLW252012P100MST | CYBERMAX
23 | L2 | 744232090 | WE 744232090 | 1 | 744232090 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/7442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 | https://www.we-online.com/components/products/download/WE-CN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 | - | - | - | -
24 | L3 | L_Small | IND_0603 | 1 | 742792651 | WÜRTH ELEKTRONIK | https://www.we-online.com/components/products/datasheet/7427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 | KICAD FB 0603 | - | C963865 | ACMS160808A1213A | HYHONGYEX
25 | LS1 | 78dB 4kHz | PKM13EPYH4000-A0 | 1 | PKM13EPYH4000-A0 | MURATA | https://www.murata.com/en-us/products/productdetail?partno=P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 | https://www.murata.com/en-us/products/productdetail?partno=P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 | THRU HOLE | - | - | -
26 | Q1, Q2, Q3 | 2N7002 | SOT-23 | 3 | 2N7002K-7 | DIODES INCORPORATED | https://www.diodes.com/datasheet/download/2N7002K.pdf | KICAD SOT-23-3 | - | C8545 | 2N7002 | JIANGSU CHANGJING
27 | R1, R11, R13, R14, R18, R2, R21, R24, R25, R26, R27, R32, R35, R36, R37, R39, R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 | 10K 1% | RES_0603 | 27 | CRCW060310K0FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C25804 | 0603WAF1002T5E | UNI-ROYAL
28 | R10, R22, R30, R31, R33, R34, R8, R9 | 1K 1% | RES_0603 | 8 | CRCW06031K00FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C21190 | 0603WAF1001T5E | UNI-ROYAL
29 | R12, R15 | 2.2K 1% | RES_0603 | 2 | CRCW06032K20FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C4190 | 0603WAF2201T5E | UNI-ROYAL
30 | R16, R17, R19, R20, R38, R4, R42, R43, R44, R5, R6, R7 | 51R 1% | RES_0603 | 12 | CRCW060351R0FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C23197 | 0603WAF510JT5E | UNI-ROYAL
31 | R23, R28 | 5.1K 1% | RES_0603 | 2 | CRCW06035K10FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C23186 | 0603WAF5101T5E | UNI-ROYAL
32 | R29 | 0R | RES_0603 | 1 | CRCW06030000Z0 | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C21189 | 0603WAF0000T5E | UNI-ROYAL
33 | R3 | 6K2 1% | RES_0603 | 1 | CRCW06036K20FK | VISHAY | https://www.we-online.com/components/products/datasheet/6130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 | KICCAD RES 0603 | - | C4260 | 0603WAF6201T5E | UNI-ROYAL
34 | SW1 | RST | SW_Push_1P1T_NO_CK_KSC6xxJ | 1 | PTS526SM20SMTR21 LFS | LITTELFUSE/C&K | https://www.ckswitches.com/media/2122/pts-flyer.pdf | https://www.ckswitches.com/products/switches/product-details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 | - | C318884 | TS-1187A-B-A-B | XKB CONNECTION
35 | SW2 | UP | SW_Push_1P1T_NO_CK_KSC6xxJ | 1 | PTS526SM20SMTR21 LFS | LITTELFUSE/C&K | https://www.ckswitches.com/media/2122/pts-flyer.pdf | https://www.ckswitches.com/products/switches/product-details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 | - | C318884 | TS-1187A-B-A-B | XKB CONNECTION
36 | SW3 | LEFT | SW_Push_1P1T_NO_CK_KSC6xxJ | 1 | PTS526SM20SMTR21 LFS | LITTELFUSE/C&K | https://www.ckswitches.com/media/2122/pts-flyer.pdf | https://www.ckswitches.com/products/switches/product-details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 | - | C318884 | TS-1187A-B-A-B | XKB CONNECTION
37 | SW4 | CENTER | SW_Push_1P1T_NO_CK_KSC6xxJ | 1 | PTS526SM20SMTR21 LFS | LITTELFUSE/C&K | https://www.ckswitches.com/media/2122/pts-flyer.pdf | https://www.ckswitches.com/products/switches/product-details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 | - | C318884 | TS-1187A-B-A-B | XKB CONNECTION
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
## Code that names these connections

File FIRMWARE/STM32XP_PROTOTYPE_BREADBOARD/STM32XP_PROTOTYPE_BREADBOARD.ioc (part):

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Mcu.Name=STM32F411R(C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F411RETx
PA0-WKUP.Signal=ADCx_IN0
PA1.Signal=ADCx_IN1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=ST7789_CS
PA10.Signal=GPIO_Output
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA15.Signal=S_TIM2_CH1_ETR
PA2.Signal=ADCx_IN2
PA3.Signal=ADCx_IN3
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=LED_USER
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=ST7789_DC
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=ST7789_RST
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PA8.GPIO_Label=BUTTON_2
PA8.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA8.Signal=GPXTI8
PA9.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PA9.GPIO_Label=BUTTON_1
PA9.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA9.Signal=GPXTI9
PB0.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB0.GPIO_Label=BUTTON_UP
PB0.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB0.Signal=GPXTI0
PB1.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB1.GPIO_Label=BUTTON_DOWN
PB1.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB1.Signal=GPXTI1
PB10.Signal=S_TIM2_CH3
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=SD_CS
PB12.Signal=GPIO_Output
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PB2.GPIO_Label=BUTTON_CENTER
PB2.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB2.Signal=GPXTI2
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=OLED_RST
PB5.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC10.GPIOParameters=GPIO_Label
PC10.GPIO_Label=SD_NIN
PC10.Signal=GPIO_Input
PC13-ANTI_TAMP.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PC13-ANTI_TAMP.GPIO_Label=BUTTON_USER
PC13-ANTI_TAMP.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC13-ANTI_TAMP.GPIO_PuPd=GPIO_PULLUP
PC13-ANTI_TAMP.Signal=GPXTI13
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC4.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC4.GPIO_Label=BUTTON_LEFT
PC4.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC4.Signal=GPXTI4
PC5.GPIOParameters=GPIO_Label,GPIO_ModeDefaultEXTI
PC5.GPIO_Label=BUTTON_RIGHT
PC5.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC5.Signal=GPXTI5
PC6.Signal=S_TIM3_CH1
PC7.Signal=S_TIM3_CH2
PC8.Signal=S_TIM3_CH3
PC9.Signal=S_TIM3_CH4
PH0\ -\ OSC_IN.Mode=HSE-External-Oscillator
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Oscillator
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=96000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2024-04-27 Project creation.
2024-04-27 Started hardware design. Created IOC file on CubeMX. Created KiCad project.
2024-04-28 Continuing schematic design and preliminary placement of components.
2024-04-29 Closed project files for commiting.
2024-05-07 Added libraries for custom components. Added OLED display. Started draft of routing.
2024-05-11 Folders reorganization.
2024-05-11 Preparation to start CubeIDE Project and prototype testing.
2024-05-11 Firmware project creation for breadboard prototype.
2024-05-11 Added logo and legend to board. Added OLED display libs to firmware.
2024-05-12 Added and tested serial port functionality.
2024-05-12 Added PWM functionality and tested using buzzer and RGB LED.
2024-05-12 Added timed interrupt.
2024-05-12 Added external interrupt to ISR; still needs debouncing.
2024-05-13 Added RGBfunctionality. Corrected SPI connections on schematic and layout.
2024-05-18 Added buttons debouncing.
2024-05-18 Refactoring.
2024-05-18 Added SD Card functionality.
2024-05-19 Added ADS1115 library and basic functionality. Refactoring of other files.
2024-05-19 Improved version visualization using __DATE__ and __TIME__ of builds.
2024-05-19 Added automatic version date to display init.
2024-05-19 Added AFE circuit.
2024-05-19 Added PWM outputs from MCU; added directional buttons; added part of buzzer circuit.
2024-07-08 Added sheets and organized schematic; added DC-DC Boost Converter; added connections to headers; general improvements on schematic and layout.
2024-07-10 Continuing layout and routing.
2024-07-11 Added new PNs for some components. Overall improvements in schematic and layout.
2024-07-13 Continuing PCB layout and routing.
2024-07-14 Trying to solve all errors on DRC, but some depend on finishing other tasks.
2024-07-15 Changed tactile switch model; had to enlarge board and adjust positioning of components; added some 3D models and comments with PNs for further reference; general layout and routing improvements.
2024-07-15 More improvements. Added 3D models. Added legends.
2024-07-16 Added stiching vias.
2024-07-17 Added fiducial marks.
2024-07-20 Improvements to layout. Fixed most of errors and warnings. Added correct footprint for Micro SD socket. Added markings and symbols to legend.
2024-07-21 Finished PCB design, but needs to be reviewed. Added all components and PNs that were missing or incorrect. Added draft of STM32 EXPLORER logo.
2024-07-21 Finished Revision 0 design. Used plugin to make manufacturing files. Purchased 5 units in JLCPCB. Let's wait to check the results! :D
2024-08-06 Started Prototype 1 board bring-up.
2024-08-07 Added PDF of the schematic. Fixed clock configuration to run the MCU from 12 MHz HSE. Tested UART, RGB, Buttons, SD Card, OLED, Buzzer, external ACD and AA filter... all good (OLED requires minor bug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
2024-08-09 Added comments about minor adjustments needed after board assembly.
2024-08-10 Added USB CDC basic driver.
2024-08-13 Added basic support for SD Card detection.
2024-08-20 Added NeoPixel driver.
2024-08-24 Added basic RTC functionality.
2024-08-24 Added RTC to OLED display. Fixed frame offset of SH1106 OLED controller. Added internal ADC (needs refactoring).
2024-08-26 Added TFT display with ST7789 controller.
2024-09-01 Added datasheets.
2024-11-03 Added updated PDF with comments after corrections in the prototype.
2024-11-08 Added complete BOM.
2024-12-07 Preparing code for demonstration for PCB Course.
2024-12-07 Don't now why these files changed.
2024-12-07 Fixed SD Card. It uses LOW polarity, but display uses HIGH.
2024-12-07 Finished recording demo classes.
2025-01-19 Added new Mechatronix Lab logo; tested firmwre on PCB Course board.
2025-01-19 Added board images.
2025-01-23 Added OSHW certification images.
2025-05-18 Added modules images.
2025-05-18 Update README.md
    Adding info about the breadbaord prototype
2025-05-18 Updated images.
2025-11-29 Fixed undefined input that was messing LEDs associated with buttons (activated internal pullup to BUTTON_USER (PC13).
