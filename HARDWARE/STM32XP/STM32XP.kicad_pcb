# Repository MechatronixLab/STM32XP

File README.md:

# STM32 Explorer Board - STM32XP
  
This is an educational development board conceived as part of a PCB Design course. The course is offered via [**Portal Embarcados**](https://embarcados.com.br/) website ([**Course Page**](https://cursos.embarcados.com.br/cursos/projeto-de-pcb-para-sistemas-embarcados/)).

## License and certification
This is an open source hardware project licensed under CERN-OHL-P. More details on [LICENSE.md](./LICENSE.md).  

[OSHW] BR000018 | Certified open source hardware | [oshwa.org/cert](https://certification.oshwa.org/br000018.html).

## Board specifications

The board is based on the [**STM32F411**](https://www.st.com/en/microcontrollers-microprocessors/stm32f411.html), more specifically, the [**STM32F411RET6**](https://www.st.com/en/microcontrollers-microprocessors/stm32f411re.html).
Additionally, the board features some components commonly used in Embedded Systems, such as:
- DC-DC Converters
- OLED Display, connected to the MCU via I²C
- RGB LEDs
- Audio buzzer, controlled via PWM
- External ADC with analog antialiasing filters
- USB 1.1 Full Speed via a Type-C connector
- Micro SD Card for easy data storage, connected to the MCU via SPI
- Input buttons
- Several I/O pins routed to breakout connectors/pins
- CR2032 Battery for RTC operation

## Firmware

A simple software application was developed to test each of the subsystems of the board.

## Tests

# Breadboard Prototype

Before commiting to this design, a breadboard prototype was assembled for validation. This prototype used a Nucleo Board, development modules whenever possible, ICs and discrete electronic components. These parts can be easily acquired on electronics stores worldwide. The connections between modules follow very closely the [final schematic](https://github.com/MechatronixLab/STM32XP/blob/master/HARDWARE/KICAD/STM32XP.pdf) of the STM32XP Board. The same firmware runs on both the prototype and STM32XP Board.

## Parts list
 
| Part                                                                                                      | Image                                                              |
|-----------------------------------------------------------------------------------------------------------|:------------------------------------------------------------------:|
| [**NUCLEO-F411RE**](https://www.st.com/en/evaluation-tools/nucleo-f411re.html)                            |              |
| Breadboard Power Supply Module                                                                            |     |
| 1.3" OLED Display Module                                                                                  |                 |
| ADS1115 ADC Module                                                                                        |              |
| Bidirectional Level Shifter Module                                                                        |  |
| Directional Tactile Switch Module                                                                         |    |
| Micro SD Card Module                                                                                      |             |
| LM324N + Passives (Anti-Aliasing Filter)                                                                  |                      |
| Passive Buzzer + 2N3904                                                                                   |                      |
| [**WSEN-ISDS**](https://www.we-online.com/en/components/products/WSEN-ISDS) (Left out of the final design)|                   |

## KiCad design HARDWARE/STM32XP/STM32XP.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Multicomp_BC-2001_1x2032
C1, C2, C3, C4, C5, C8: 100nF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7, C11: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10: 10pF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: Micro_SD_Card; microSD_HC_Wuerth_693072010801
J3, J4: Conn_01x20_Socket; PinSocket_1x20_P2.54mm_Horizontal
J5: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
J9: Conn_02x05_Odd_Even; PinSocket_2x05_P2.54mm_Horizontal
L1: L_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R1: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; SW_SPST_CK_KXT3
SW3: RST; SW_SPST_CK_KXT3
U1: STM32F411RETx; LQFP-64_10x10mm_P0.5mm
U2: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm
U3: LM324; TSSOP-14_4.4x5mm_P0.65mm
U4: AMS1117-3.3; SOT-223-3_TabPin2
Y1: 32.768kHz; Crystal_SMD_G8-2Pin_3.2x1.5mm_HandSoldering
Y2: 8MHz xpF; Crystal_SMD_EuroQuartz_MT-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C1.2, C2.2, C3.2, C4.2, C7.2, L1.1, U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD)
+3.3VA: C5.2, C6.2, L1.2, U1.13 (VDDA)
+3VBAT: BT1.1 (+), C8.2, U1.1 (VBAT)
GND: BT1.2 (-), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), Y2.2, Y2.4
unnamed: C9.2, R2.1, Y2.1
unnamed: J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND)
unnamed: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: R1.2, U1.60 (BOOT0)
unnamed: U1.3 (PC14), Y1.2
unnamed: U1.4 (PC15), Y1.1
unnamed: C10.2, U1.5 (PH0), Y2.3
unnamed: R2.2, U1.6 (PH1)
VCORE: C11.2, U1.30 (VCAP1)

Board: 2 copper layers, 34 parts (1 on the bottom side), 13 nets, no tracks yet.

## KiCad design HARDWARE/KICAD/STM32XP.kicad_pcb

Notes on the sheet:
BUCK-BOOST TI TPS63070 https://www.ti.com/lit/ds/symlink/tps63070.pdf?ts=1715008161102 4-WAY SWITCH https://jlcpcb.com/partdetail/ShouHan-7_7_5_6P_LWX/C2858287

Parts:
C5, C11, C17, C18, C24, C32, C35, C41, C42, C43: 100nF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15, C25, C31: 10pF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C36, C37, C44: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
L3: L_Small; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q2, Q3: 2N7002; SOT-23
R11, R14, R18, R32: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R15: 2.2K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17, R19, R20, R38, R42, R43: 51R 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R31, R33, R34: 1K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RST; SW_Push_1P1T_NO_CK_KSC6xxJ
TP10: +3.3VA; TestPoint_Keystone_5000-5004_Miniature
TP12: +VCORE; TestPoint_Keystone_5000-5004_Miniature
TP15: PD2; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP16: PC11; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP17: PC12; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP18: PB5; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP19: PB4; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP20: PC13; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP21: PB10; TestPoint_THTPad_D1.0mm_Drill0.5mm
U8: STM32F411RETx; LQFP-64_10x10mm_P0.5mm
Y1: 32.768kHz; Crystal_SMD_G8-2Pin_3.2x1.5mm_HandSoldering
Y2: 12MHz 20Pppm 18pF; Crystal_SMD_EuroQuartz_MT-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: C11.2, C18.2, C24.2, C36.2, C41.2, C42.2, L3.1, Q2.1 (G), Q3.1 (G), R12.2, R15.2, R32.2, U8.19 (VDD), U8.32 (VDD), U8.48 (VDD), U8.64 (VDD); also elsewhere on the board
+3.3VA: C35.2, C37.2, L3.2, TP10.1, U8.13 (VDDA)
+3VBAT: C17.2, U8.1 (VBAT); also elsewhere on the board
+5V: C5.2, R11.2, R14.2; also elsewhere on the board
+VCORE: C43.2, C44.2, TP12.1, U8.30 (VCAP1)
/MCU/BOOT0: R18.2, U8.60 (BOOT0)
/MCU/HSE OUT: C31.2, R29.1, Y2.1
/MCU/LSE IN: C15.2, U8.3 (PC14), Y1.2
/MCU/LSE OUT: C14.2, U8.4 (PC15), Y1.1
/MCU/PA15: R20.1, U8.50 (PA15)
/MCU/PB4: TP19.1, U8.56 (PB4)
/MCU/PB5: TP18.1, U8.57 (PB5)
/MCU/PB6: R19.1, U8.58 (PB6)
/MCU/PB8: R17.1, U8.61 (PB8)
/MCU/PB9: R16.1, U8.62 (PB9)
/MCU/PB10: TP21.1, U8.29 (PB10)
/MCU/PB12 SPI: R43.1, U8.33 (PB12)
/MCU/PB13 SPI: R42.1, U8.34 (PB13)
/MCU/PB15 SPI: R38.1, U8.36 (PB15)
/MCU/PC11: TP16.1, U8.52 (PC11)
/MCU/PC12: TP17.1, U8.53 (PC12)
/MCU/PC13: TP20.1, U8.2 (PC13)
/MCU/PD2: TP15.1, U8.54 (PD2)
/MCU/PH0: C25.2, U8.5 (PH0), Y2.3
/MCU/PH1: R29.2, U8.6 (PH1)
/MCU/TIM3 CH1: R34.2, U8.37 (PC6)
/MCU/TIM3 CH2: R33.2, U8.38 (PC7)
/MCU/TIM3 CH3: R31.2, U8.39 (PC8)
/MCU/TIM3 CH4: R30.2, U8.40 (PC9)
BUTTON 1: U8.41 (PA8); also elsewhere on the board
BUTTON 2: U8.42 (PA9); also elsewhere on the board
BUTTON CENTER: U8.28 (PB2); also elsewhere on the board
BUTTON DOWN: U8.27 (PB1); also elsewhere on the board
BUTTON LEFT: U8.24 (PC4); also elsewhere on the board
BUTTON RIGHT: U8.25 (PC5); also elsewhere on the board
BUTTON UP: U8.26 (PB0); also elsewhere on the board
DEBUG RX: U8.59 (PB7); also elsewhere on the board
DEBUG TX: R19.2; also elsewhere on the board
GND: C5.1, C11.1, C14.1, C15.1, C17.1, C18.1, C24.1, C25.1, C31.1, C32.1, C35.1, C36.1, C37.1, C41.1, C42.1, C43.1, C44.1, R18.1, SW1.1, U8.12 (VSSA), U8.18 (VSS), U8.31 (VSS), U8.47 (VSS), U8.63 (VSS), Y2.2, Y2.4; also elsewhere on the board
I2C SCL 3.3V: Q2.2 (S), R12.1, R17.2; also elsewhere on the board
I2C SCL 5V: Q2.3 (D), R11.1; also elsewhere on the board
I2C SDA 3.3V: Q3.2 (S), R15.1, R16.2; also elsewhere on the board
I2C SDA 5V: Q3.3 (D), R14.1; also elsewhere on the board
NEOPIXEL DIN: R20.2; also elsewhere on the board
NRST: C32.2, R32.1, SW1.2, U8.7 (NRST); also elsewhere on the board
PA0: U8.14 (PA0); also elsewhere on the board
PA1: U8.15 (PA1); also elsewhere on the board
PA2: U8.16 (PA2); also elsewhere on the board
PA3: U8.17 (PA3); also elsewhere on the board
PA4: U8.20 (PA4); also elsewhere on the board
PA5: U8.21 (PA5); also elsewhere on the board
PA6: U8.22 (PA6); also elsewhere on the board
PA7: U8.23 (PA7); also elsewhere on the board
PC0: U8.8 (PC0); also elsewhere on the board
PC1: U8.9 (PC1); also elsewhere on the board
PC2: U8.10 (PC2); also elsewhere on the board
PC3: U8.11 (PC3); also elsewhere on the board
PWM BLUE: R31.1; also elsewhere on the board
PWM BUZZER: R30.1; also elsewhere on the board
PWM GREEN: R33.1; also elsewhere on the board
PWM RED: R34.1; also elsewhere on the board
SD CARD ~IN: U8.51 (PC10); also elsewhere on the board
SPI MISO: U8.35 (PB14); also elsewhere on the board
SPI MOSI: R38.2; also elsewhere on the board
SPI NSS: R43.2; also elsewhere on the board
SPI SCK: R42.2; also elsewhere on the board
SWCLK: U8.49 (PA14); also elsewhere on the board
SWDIO: U8.46 (PA13); also elsewhere on the board
SWO: U8.55 (PB3); also elsewhere on the board
USB D+: U8.45 (PA12); also elsewhere on the board
USB D-: U8.44 (PA11); also elsewhere on the board
USB OTG ID: U8.43 (PA10); also elsewhere on the board

Notes on the sheet:
FB4
WE 830055295 12 MHz 20 ppm 18pF https://www.we-online.com/en/components/products/WE-XTAL#/articles/CFPX-180
SEIKO SC-32S32.768kHz20PPM12.5pF https://www.lcsc.com/datasheet/lcsc_datasheet_1811151435_Seiko-SC-32S32-768kHz20PPM12-5pF_C97606.pdf SEIKO EPSON Q13FC13500004 https://www.lcsc.com/datasheet/lcsc_datasheet_2404180925_Seiko-Epson-Q13FC13500004_C32346.pdf

Parts:
C16: 680nF 16V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C40: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26, C45: 100nF 50V; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
FB2, FB3: 600R; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J6: Conn_01x20_Socket; PinSocket_1x20_P2.54mm_Horizontal
J4: USB TYPE C; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J5: MICRO SD; WE 693071020811
L2: 744232090; WE 744232090
R4, R5, R6, R7, R44: 51R 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23, R28: 5.1K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R37, R41, R45, R48: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP8: +VBUS; TestPoint_Keystone_5000-5004_Miniature
U5: USBLC6-2SC6; SOT-23-6

Connections:
+3.3V: C40.2, C45.2, J1.1, J5.4 (VDD), J6.20, R37.2, R41.2, R45.2, R48.2; also elsewhere on the board
+5V: J1.20; also elsewhere on the board
+VBUS: C19.1, C26.1, FB3.2, J4.A4 (VBUS), J4.A9 (VBUS), J4.B4 (VBUS), J4.B9 (VBUS), TP8.1, U5.5 (VBUS)
+VBUSF: FB2.1; also elsewhere on the board
/IO/NRST CONN: J1.6, R4.2
/IO/SD DAT0 SPI: J5.7 (DAT0), R44.2
/IO/SD DAT1 SPI: J5.8 (DAT1), R45.1
/IO/SD DAT2 SPI: J5.1 (DAT2), R41.1
/IO/SWCLK CONN: J1.4, R6.2
/IO/SWDIO CONN: J1.3, R7.2
/IO/SWO CONN: J1.5, R5.2
/IO/USB CC1: J4.A5 (CC1), R28.2
/IO/USB CC2: J4.B5 (CC2), R23.2
/IO/USB DATA+: J4.A6 (D+), J4.B6 (D+), U5.6 (I/O1)
/IO/USB DATA-: J4.A7 (D-), J4.B7 (D-), U5.4 (I/O2)
/IO/USB FILTERED D+: L2.3, U5.1 (I/O1)
/IO/USB FILTERED D-: L2.2, U5.3 (I/O2)
/IO/USB FILTERED POWER: C16.1, FB2.2, FB3.1
DEBUG RX: J1.8; also elsewhere on the board
DEBUG TX: J1.7; also elsewhere on the board
GND: C16.2, C19.2, C26.2, C40.1, C45.1, J1.2, J1.15, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.6 (VSS), J5.10 (SHIELD), J5.11 (SHIELD), J5.12 (SHIELD), J5.13 (SHIELD), J6.9, J6.19, R23.1, R28.1, U5.2 (GND); also elsewhere on the board
I2C SCL 3.3V: J1.10; also elsewhere on the board
I2C SCL 5V: J1.17; also elsewhere on the board
I2C SDA 3.3V: J1.9; also elsewhere on the board
I2C SDA 5V: J1.16; also elsewhere on the board
NEOPIXEL DIN: J1.18; also elsewhere on the board
NEOPIXEL DOUT: J1.19; also elsewhere on the board
NRST: R4.1; also elsewhere on the board
PA0: J6.1; also elsewhere on the board
PA1: J6.2; also elsewhere on the board
PA2: J6.3; also elsewhere on the board
PA3: J6.4; also elsewhere on the board
PA4: J6.5; also elsewhere on the board
PA5: J6.6; also elsewhere on the board
PA6: J6.7; also elsewhere on the board
PA7: J6.8; also elsewhere on the board
PC0: J1.14; also elsewhere on the board
PC1: J1.13; also elsewhere on the board
PC2: J1.12; also elsewhere on the board
PC3: J1.11; also elsewhere on the board
PWM BLUE: J6.16; also elsewhere on the board
PWM BUZZER: J6.17; also elsewhere on the board
PWM GREEN: J6.15; also elsewhere on the board
PWM RED: J6.14; also elsewhere on the board
SD CARD ~IN: J5.9 (DET), R48.1; also elsewhere on the board
SPI MISO: J6.10, R44.1; also elsewhere on the board
SPI MOSI: J5.3 (CMD), J6.11; also elsewhere on the board
SPI NSS: J5.2 (DAT3/CD), J6.13, R37.1; also elsewhere on the board
SPI SCK: J5.5 (CLK), J6.12; also elsewhere on the board
SWCLK: R6.1; also elsewhere on the board
SWDIO: R7.1; also elsewhere on the board
SWO: R5.1; also elsewhere on the board
USB D+: L2.4; also elsewhere on the board
USB D-: L2.1; also elsewhere on the board
USB OTG ID: J6.18; also elsewhere on the board

Parts:
FID1, FID2, FID3: Fiducial; Fiducial_0.75mm_Mask1.5mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3

Parts:
BT1: CR2032; BatteryHolder_Keystone_1060_1x2032
C2, C4, C7, C8, C9, C10, C13: 10uF 25V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3, D4, D7, D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: STPS1L40-Y; D_SOD-123
D6: BAT54C; SOT-23
FB1: 600R; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J2: Jack-DC; BarrelJack_GCT_DCJ200-10-A_Horizontal
JP1: 9V; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: VSEL; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 10uH; WE 74404024100
R1, R2, R13, R21: 10K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 6K2 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R22: 1K 1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP4, TP13, TP14: GND; TestPoint_Keystone_5000-5004_Miniature
TP2: +5V; TestPoint_Keystone_5000-5004_Miniature
TP3: +3.3V; TestPoint_Keystone_5000-5004_Miniature
TP5: +9V; TestPoint_Keystone_5000-5004_Miniature
TP6: +VSEL; TestPoint_Keystone_5000-5004_Miniature
TP7: +VEXT; TestPoint_Keystone_5000-5004_Miniature
TP9: +3VBAT; TestPoint_Keystone_5000-5004_Miniature
TP11: +5VA; TestPoint_Keystone_5000-5004_Miniature
U1: AMS1117-5.0; SOT-223-3_TabPin2
U2: AMS1117-3.3; SOT-223-3_TabPin2
U3: AP3012; SOT-23-5

Connections:
+3.3V: C9.2, D4.2 (A), TP3.1, U2.2 (VO); also elsewhere on the board
+3VBAT: BT1.1 (+), TP9.1; also elsewhere on the board
+5V: C7.2, D3.2 (A), FB1.1, TP2.1, U1.2 (VO); also elsewhere on the board
+5VA: C13.2, FB1.2, TP11.1; also elsewhere on the board
+9V: C8.2, D1.2 (A), JP1.2 (B), TP5.1, U1.3 (VI); also elsewhere on the board
+VBUSF: D6.1, D7.2 (A); also elsewhere on the board
+VEXT: D6.2, D8.2 (A), J2.1, TP7.1
+VSEL: C10.2, D6.3, JP2.1 (A), TP6.1, U2.3 (VI)
/POWER/+3.3V LED: D4.1 (K), R10.2
/POWER/+5V LED: D3.1 (K), R9.2
/POWER/+9V LED: D1.1 (K), R1.2
/POWER/+VBUSF LED: D7.1 (K), R21.2
/POWER/+VEXT LED: D8.1 (K), R22.2
/POWER/BOOST FB: R2.2, R3.1, U3.3 (FB)
/POWER/BOOST IN: C4.2, JP2.2 (B), L1.1, R13.2, U3.5 (IN)
/POWER/BOOST OUT: C2.2, D2.1 (K), JP1.1 (A), R3.2
/POWER/BOOST SW: D2.2 (A), L1.2, U3.1 (SW)
/POWER/BOOST ~SHDN: R13.1, U3.4 (~SHDN)
GND: BT1.2 (-), C2.1, C4.1, C7.1, C8.1, C9.1, C10.1, C13.1, J2.2, R1.1, R2.1, R9.1, R10.1, R21.1, R22.1, TP1.1, TP4.1, TP13.1, TP14.1, U1.1 (GND), U2.1 (GND), U3.2 (GND); also elsewhere on the board

Notes on the sheet:
2024.08.09: R2 = 3.6K // 3.6K R3 = 10K VOUT = 1.25 * (1 + R3/R2) = 8.2V
VOUT = 1.25 * (R42/R43) https://jansson.us/resistors.html
WE 79527141 https://www.we-online.com/en/components/products/BCPH_BATTERY_HOLDER
